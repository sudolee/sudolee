## embedded/buildroot/matti/Config.in
```kconfig
config BR2_PACKAGE_MATTI
	bool "matti"
	help
	  Testing package for Matti Lee

	  http://www.MattiLee.com
```
